# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: 1.bat
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User;..\..\User\plc;..\..\User\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c stm32f10x_it.c global.h board.c pelco_d.h cam.c
    ./: CopyHex_Flash.bat
    ../../User/bsp/: FK.c BD.c SBUS.c Gimbal.c
  group BSP
    ../../User/bsp/: bsp_usart.c bsp_printf.c bsp_timer.c bsp_spi_flash.c camera.c 18b20.c rtc.c download.c dev_state.c flashmgr.c localTime.c uartPort.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_pwr.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_iwdg.c stm32f10x_adc.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RTT
    ../../User/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.1.0
